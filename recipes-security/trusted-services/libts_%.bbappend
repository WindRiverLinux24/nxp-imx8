COMPATIBLE_MACHINE:nxp-imx8 = "nxp-imx8"
