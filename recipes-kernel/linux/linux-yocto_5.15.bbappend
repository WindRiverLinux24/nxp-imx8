require linux-yocto-nxp-imx8.inc

KBRANCH:nxp-imx8  = "v5.15/standard/nxp-sdk-5.15/nxp-soc"

LINUX_VERSION:nxp-imx8 ?= "5.15.x"
