require linux-yocto-nxp-imx8.inc

KBRANCH:nxp-imx8  = "v6.6/standard/preempt-rt/nxp-sdk-6.6/nxp-soc"
