require linux-yocto-nxp-imx8.inc

KBRANCH:nxp-imx8  = "v5.15/standard/preempt-rt/nxp-sdk-5.15/nxp-soc"

LINUX_VERSION_nxp-imx8 ?= "5.15.x"
