require linux-yocto-nxp-imx8.inc

KBRANCH:nxp-imx8  = "v5.10/standard/nxp-sdk-5.10/nxp-soc"

LINUX_VERSION:nxp-imx8 ?= "5.10.x"
