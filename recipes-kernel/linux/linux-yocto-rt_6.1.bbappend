require linux-yocto-nxp-imx8.inc

KBRANCH:nxp-imx8  = "v6.1/standard/nxp-sdk-6.1/nxp-soc"
